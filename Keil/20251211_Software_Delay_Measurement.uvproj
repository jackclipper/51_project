# Keil uVision project 20251211_Software_Delay_Measurement.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Software_Delay_Measurement +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Software_Delay_Measurement.c
